CMDLINE_ROOT_FSTYPE:append:revpi = " fsck.repair=yes"

CMDLINE:append:revpi = " console=tty1 nosplash plymouth.ignore-serial-consoles"
