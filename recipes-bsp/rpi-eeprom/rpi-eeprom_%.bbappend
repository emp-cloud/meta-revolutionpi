COMPATIBLE_MACHINE += "|revpi"
